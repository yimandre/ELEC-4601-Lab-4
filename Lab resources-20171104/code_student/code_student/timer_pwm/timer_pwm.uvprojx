# Keil uVision project timer_pwm.uvprojx, settings and files
target mbed NUCLEO_F401RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer_pwm
  c flags: Optim=1
  c define: TARGET_NUCLEO_F401RE,  TARGET_M4,  TARGET_STM,  TARGET_STM32F4,  TARGET_STM32F401RE,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M4,  ARM_MATH_CM4,  __FPU_PRESENT=1,  MBED_BUILD_TIMESTAMP=1407326088.15,  __MBED__=1,  TARGET_FF_ARDUINO,  TARGET_FF_MORPHO,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;mbed;mbed/TARGET_NUCLEO_F401RE;mbed/TARGET_NUCLEO_F401RE/TARGET_STM;mbed/TARGET_NUCLEO_F401RE/TARGET_STM/TARGET_NUCLEO_F401RE;mbed/TARGET_NUCLEO_F401RE/TOOLCHAIN_ARM_MICRO;.\headers;.\mbed-rtos\;.\mbed-rtos\rtos;.\mbed-rtos\rtx;.\mbed-rtos\rtx\.*;.\mbed-rtos\rtx\.*\TOOLCHAIN_ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ./mbed/stm32f401xe.sct
  link misc: mbed/stm32f4xx_hal_pwr.o
            
              mbed/stm32f4xx_ll_fsmc.o
            
              mbed/hal_tick.o
            
              mbed/stm32f4xx_hal_wwdg.o
            
              mbed/stm32f4xx_hal_tim_ex.o
            
              mbed/stm32f4xx_hal_eth.o
            
              mbed/stm32f4xx_hal_flash_ex.o
            
              mbed/stm32f4xx_hal_irda.o
            
              mbed/sys.o
            
              mbed/stm32f4xx_hal_dma_ex.o
            
              mbed/stm32f4xx_ll_sdmmc.o
            
              mbed/stm32f4xx_hal_crc.o
            
              mbed/stm32f4xx_hal_sram.o
            
              mbed/stm32f4xx_hal_i2c.o
            
              mbed/cmsis_nvic.o
            
              mbed/stm32f4xx_hal_dma.o
            
              mbed/stm32f4xx_hal_hash_ex.o
            
              mbed/stm32f4xx_hal_rcc_ex.o
            
              mbed/stm32f4xx_hal_cortex.o
            
              mbed/stm32f4xx_hal_flash.o
            
              mbed/stm32f4xx_hal_rcc.o
            
              mbed/stm32f4xx_hal_tim.o
            
              mbed/stm32f4xx_hal_pccard.o
            
              mbed/stm32f4xx_hal_i2c_ex.o
            
              mbed/stm32f4xx_ll_fmc.o
            
              mbed/stm32f4xx_ll_usb.o
            
              mbed/stm32f4xx_hal_cryp.o
            
              mbed/stm32f4xx_hal_cryp_ex.o
            
              mbed/stm32f4xx_hal_adc.o
            
              mbed/stm32f4xx_hal_smartcard.o
            
              mbed/stm32f4xx_hal_ltdc.o
            
              mbed/stm32f4xx_hal_rtc_ex.o
            
              mbed/stm32f4xx_hal_sd.o
            
              mbed/stm32f4xx_hal_dac_ex.o
            
              mbed/stm32f4xx_hal_sai.o
            
              mbed/stm32f4xx_hal_i2s_ex.o
            
              mbed/stm32f4xx_hal_sdram.o
            
              mbed/stm32f4xx_hal_rtc.o
            
              mbed/stm32f4xx_hal_pcd.o
            
              mbed/stm32f4xx_hal.o
            
              mbed/stm32f4xx_hal_dcmi.o
            
              mbed/stm32f4xx_hal_gpio.o
            
              mbed/stm32f4xx_hal_adc_ex.o
            
              mbed/mbed_overrides.o
            
              mbed/stm32f4xx_hal_hash.o
            
              mbed/stm32f4xx_hal_pwr_ex.o
            
              mbed/stm32f4xx_hal_can.o
            
              mbed/stm32f4xx_hal_dac.o
            
              mbed/system_stm32f4xx.o
            
              mbed/stm32f4xx_hal_spi.o
            
              mbed/stm32f4xx_hal_uart.o
            
              mbed/stm32f4xx_hal_usart.o
            
              mbed/stm32f4xx_hal_dma2d.o
            
              mbed/startup_stm32f401xe.o
            
              mbed/board.o
            
              mbed/stm32f4xx_hal_nor.o
            
              mbed/stm32f4xx_hal_rng.o
            
              mbed/retarget.o
            
              mbed/stm32f4xx_hal_iwdg.o
            
              mbed/stm32f4xx_hal_nand.o
            
              mbed/stm32f4xx_hal_i2s.o
            
              mbed/stm32f4xx_hal_hcd.o
            
              mbed/mbed.ar
  group src
    ./src/: main.cpp
